# Keil uVision project Template.uvproj, settings and files
target Template (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: NUC240LD2AE Nuvoton
  cpu: IRAM(0x20000000-0x20001FFF) IROM(0-0xFFFF) CLOCK(72000000) CPUTYPE("Cortex-M0")
  output: template +hex
  AfterMake: fromelf --bin ".\objects\@L.axf" --output ".\objects\@L.bin"
  AfterMake: fromelf --text -c ".\objects\@L.axf" --output ".\objects\@L.txt"
  c flags: OneElfS=1 v6Lang=1 v6LangP=1
  c include: ..\NUC230_240BSP\Library\CMSIS\Include;..\NUC230_240BSP\Library\Device\Nuvoton\NUC230_240\Include;..\NUC230_240BSP\Library\StdDriver\inc
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x2000
  link misc: --map --first='startup_NUC230_240.o(RESET)' --datacompressor=off --info=inline --entry Reset_Handler
  group CMSIS
    ../NUC230_240BSP/Library/Device/Nuvoton/NUC230_240/Source/ARM/: startup_NUC230_240.s
    ../NUC230_240BSP/Library/Device/Nuvoton/NUC230_240/Source/: system_NUC230_240.c
  group User
    ./: main.c
  group Library
    ../NUC230_240BSP/Library/StdDriver/src/: retarget.c uart.c sys.c clk.c
